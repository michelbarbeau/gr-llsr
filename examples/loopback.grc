<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_2</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_3</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>5</value></param>
<param><key>minsize</key><value>5</value></param>
</block>
<block>
<key>llsr_llsr_mac</key>
<param><key>id</key><value>llsr_llsr_mac_0</value></param>
<param><key>timeout</key><value>0.01</value></param>
<param><key>addr</key><value>1</value></param>
<param><key>backoff_randomness</key><value>0.05</value></param>
<param><key>exp_backoff</key><value>True</value></param>
<param><key>broadcast_interval</key><value>2</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug_level</key><value>0</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>maximum_attempts</key><value>5</value></param>
<param><key>max_queue_size</key><value>10</value></param>
<param><key>node_expiry_delay</key><value>10.0</value></param>
</block>
<block>
<key>llsr_llsr_mac</key>
<param><key>id</key><value>llsr_llsr_mac_1</value></param>
<param><key>timeout</key><value>0.01</value></param>
<param><key>addr</key><value>0</value></param>
<param><key>backoff_randomness</key><value>0.05</value></param>
<param><key>exp_backoff</key><value>True</value></param>
<param><key>broadcast_interval</key><value>2</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug_level</key><value>0</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>maximum_attempts</key><value>5</value></param>
<param><key>max_queue_size</key><value>10</value></param>
<param><key>node_expiry_delay</key><value>10.0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>llsr_llsr_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_2</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_3</source_block_id><sink_block_id>llsr_llsr_mac_1</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>llsr_llsr_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>from_app_arq</sink_key></connection>
<connection><source_block_id>llsr_llsr_mac_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>to_app</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>llsr_llsr_mac_0</source_block_id><sink_block_id>llsr_llsr_mac_1</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>llsr_llsr_mac_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>to_app</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>llsr_llsr_mac_1</source_block_id><sink_block_id>llsr_llsr_mac_0</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
</flow_graph>
